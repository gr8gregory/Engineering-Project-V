# Keil uVision project Menu_Nucleo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Menu_Nucleo
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: GPIO.c GPIO.h LED.c LED.h main.c startup_stm32f303xe.s SysClock.c SysClock.h USART.c USART.h utils.h virtualPort.c virtualPort.h system_stm32f3xx.c Heartbeat.c Heartbeat.h stepper.c stepper.h limit.c limit.h servo.h servo.c timer.h
software components: CMSIS:CORE 5.3.0
